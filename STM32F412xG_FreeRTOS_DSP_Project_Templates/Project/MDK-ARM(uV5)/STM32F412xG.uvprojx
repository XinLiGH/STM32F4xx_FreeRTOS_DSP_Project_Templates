# Keil uVision project STM32F412xG.uvprojx, settings and files
target STM32F412xG (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F412CGUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F412xG +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\MDK-ARM(uV5)\Objects\STM32F412xG.bin ..\MDK-ARM(uV5)\Objects\STM32F412xG.axf
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F412xG,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --C99
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\FreeRTOS\inc;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../../Libraries/CMSIS/startup/: startup_stm32f412xg.s
  group User
    ../../USER/: stm32f4xx_it.c main.c
  group FreeRTOS
    ../../Libraries/FreeRTOS/src/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c misc.c stm32f4xx_rng.c stm32f4xx_can.c stm32f4xx_qspi.c stm32f4xx_fsmc.c stm32f4xx_dfsdm.c
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f4xx.c
  group DSP_Lib
    ../../Libraries/CMSIS/: arm_cortexM4lf_math.lib
