# Keil uVision project STM32F446xx.uvprojx, settings and files
target STM32F446xx (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F446MCYx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F446xx +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\MDK-ARM(uV5)\Objects\STM32F446xx.bin ..\MDK-ARM(uV5)\Objects\STM32F446xx.axf
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F446xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --C99
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\FreeRTOS\inc;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../../Libraries/CMSIS/startup/: startup_stm32f446xx.s
  group User
    ../../USER/: stm32f4xx_it.c main.c
  group FreeRTOS
    ../../Libraries/FreeRTOS/src/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c misc.c stm32f4xx_cryp.c stm32f4xx_hash.c stm32f4xx_rng.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_fmc.c stm32f4xx_ltdc.c stm32f4xx_sai.c stm32f4xx_qspi.c stm32f4xx_fmpi2c.c stm32f4xx_spdifrx.c stm32f4xx_cec.c
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f4xx.c
  group DSP_Lib
    ../../Libraries/CMSIS/: arm_cortexM4lf_math.lib
